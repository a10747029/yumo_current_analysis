## apps/examples/current_main/Kconfig
```kconfig
config EXAMPLES_CURRENT_MAIN
	bool "Current main example"
	default n
	---help---
		Simple current main example.
```
